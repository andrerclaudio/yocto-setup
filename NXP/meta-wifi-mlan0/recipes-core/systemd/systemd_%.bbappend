PACKAGECONFIG:append = " networkd resolved"
RDEPENDS:${PN}:append = " add-conn-wifi"